# IAR project Project.ewp, settings and files
configuration STM32F429_439xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX; USE_STM324x7I_EVAL; USART1_USED_; USART1_WELLCOME_; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL; ..\..\..\Libraries\LNQ\inc; ..\..\..\Libraries\LNQ\cpp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F427_437xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F437II ST STM32F437II
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F427_437xx; USE_STM324x7I_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM32F40_41xxx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F417IG ST STM32F417IG
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; USE_STM324xG_EVAL
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
configuration STM32F401xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F401xC ST STM32F401xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  group CMSIS
    ../../../Libraries/CMSIS/Include/: core_cm4.h core_cm4_simd.h
    ../: system_stm32f4xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s
  group LNQ
    ../../../Libraries/LNQ/inc/: GPIO.h
  group LNQ/ADC
    ../../../Libraries/LNQ/src/: AD.c
    ../../../Libraries/LNQ/inc/: AD.h
  group LNQ/common
    ../../../Libraries/LNQ/src/: common.c malloc.c PINGPANG.c
    ../../../Libraries/LNQ/inc/: common.h malloc.h PINGPANG.h Sequeue.h
  group LNQ/CPP
    ../../../Libraries/LNQ/cpp/: NumBar_CPP.cpp NumBar_CPP.h SelectBar_L.cpp SelectBar_L.h String_L.cpp String_L.h
  group LNQ/DAC
    ../../../Libraries/LNQ/src/: DA.c
    ../../../Libraries/LNQ/inc/: DA.h
  group LNQ/EXIT
    ../../../Libraries/LNQ/src/: exti.c
    ../../../Libraries/LNQ/inc/: exti.h
  group LNQ/LCD
    ../../../Libraries/LNQ/src/: FONT.c LCD.c
    ../../../Libraries/LNQ/inc/: FONT.h LCD.h
  group LNQ/LCD/Curve
    ../../../Libraries/LNQ/src/: LCD_Curve.c
    ../../../Libraries/LNQ/inc/: LCD_Curve.h
  group LNQ/LCD/String
    ../../../Libraries/LNQ/src/: LCD_String.c
    ../../../Libraries/LNQ/inc/: LCD_String.h
  group LNQ/LCD/Tools
    ../../../Libraries/LNQ/src/: LCD_Tools.c NumBar.c SelectBar.c SelectItem.c
    ../../../Libraries/LNQ/inc/: LCD_Tools.h NumBar.h SelectBar.h SelectItem.h
  group LNQ/NRF2401
    ../../../Libraries/LNQ/src/: NRF2401.c
    ../../../Libraries/LNQ/inc/: NRF2401.h
  group LNQ/SPI
    ../../../Libraries/LNQ/src/: SPI.c
    ../../../Libraries/LNQ/inc/: SPI.h
  group LNQ/SPI/ADS1220
    ../../../Libraries/LNQ/src/: ADS1220.c
    ../../../Libraries/LNQ/inc/: ADS1220.h
  group LNQ/Timer
    ../../../Libraries/LNQ/src/: Timer.c
    ../../../Libraries/LNQ/inc/: Timer.h
  group LNQ/USART
    ../../../Libraries/LNQ/src/: USART.c
    ../../../Libraries/LNQ/inc/: USART.h
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: Data.c Data.h Freq.cpp Freq.h Impluse.cpp Impluse.h main.cpp main.h Span.cpp Span.h stm32f4xx_it.c
